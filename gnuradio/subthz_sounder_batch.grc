options:
  parameters:
    author: Group 10 - P. Bhaskar, A. Tripathi, A. K. Pandey
    description: 'GNU Radio implementation of the measurement chain of Cheng et al. (IEEE TWC 2026): cluster-model channel -> per-orientation 1001-tone VNA sweep -> sounder noise -> IFFT -> |.|^2/N_f (Eq. 1) -> ADPS, 35 dB MPC threshold, delay/angular spreads and path gains (Sec. VIII). Run from the command line: python subthz_sounder_batch.py --condition nlos --n-channels 17 --out-csv out.csv'
    generate_options: no_gui
    id: subthz_sounder_batch
    output_language: python
    run_options: run
    title: Sub-THz 145 GHz D2D channel sounder (batch validation)
  states: {}

blocks:
- name: import_np
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: condition
  id: parameter
  parameters:
    label: Condition (los / nlos)
    type: str
    value: los
  states: {}
- name: n_channels
  id: parameter
  parameters:
    label: Number of channel realizations
    type: intx
    value: '4'
  states: {}
- name: start_index
  id: parameter
  parameters:
    label: First realization index
    type: intx
    value: '0'
  states: {}
- name: seed
  id: parameter
  parameters:
    label: Seed
    type: intx
    value: '20260723'
  states: {}
- name: distances
  id: parameter
  parameters:
    label: Link distances (measured / uniform)
    type: str
    value: measured
  states: {}
- name: params_file
  id: parameter
  parameters:
    label: Parameter YAML ('' = Table I)
    type: str
    value: ''
  states: {}
- name: snr_db
  id: parameter
  parameters:
    label: Sounder SNR per tone (dB below strongest tap)
    type: eng_float
    value: '60.0'
  states: {}
- name: out_csv
  id: parameter
  parameters:
    label: Output CSV
    type: str
    value: sounder.csv
  states: {}
- name: nf
  id: variable
  parameters:
    value: '1001'
    comment: 1001 tones, 145-146 GHz (1 MHz spacing, 1 ns delay bins)
  states: {}
- name: dr_db
  id: variable
  parameters:
    value: '35.0'
    comment: MPC threshold below the ADPS maximum (Sec. IV-A)
  states: {}
- name: vna
  id: epy_block
  parameters:
    _source_code: |
      def _repo_src():
          import os, sys
          cands = [os.environ.get("SUBTHZ_REPO", "")]
          try:
              cands.append(os.path.join(os.path.dirname(os.path.abspath(__file__)), ".."))
          except NameError:
              pass
          cwd = os.getcwd()
          cands += [cwd, os.path.join(cwd, ".."), os.path.join(cwd, "..", "..")]
          for c in cands:
              src = os.path.join(c, "src")
              if c and os.path.isdir(os.path.join(src, "channel_model")):
                  if src not in sys.path:
                      sys.path.insert(0, os.path.abspath(src))
                  return os.path.abspath(c)
          raise RuntimeError("cannot find the sub-thz-d2d-channel-model repository; set SUBTHZ_REPO")


      import json
      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):
          """Cluster-model channel + VNA sweep generator.

          For every channel realization (Sec. VI generator) and every one of the 36 x 36 Tx/Rx horn
          orientations this block emits one vector of 1001 complex tones H(f), 145-146 GHz.
          The first vector of a realization carries tags: rid, d_m, gain_db (peak normalisation)
          and truth (metrics of the generator's own ADPS, for verification of the sounder chain).
          The flowgraph ends after n_channels realizations.
          """

          def __init__(self, condition="los", n_channels=4, start_index=0, seed=20260723,
                       distances="measured", params_file=""):
              gr.sync_block.__init__(self, name="Sub-THz cluster channel + VNA sweep",
                                     in_sig=None, out_sig=[(np.complex64, 1001)])
              self.condition, self.n_channels, self.start_index = condition, int(n_channels), int(start_index)
              self.seed, self.distances, self.params_file = int(seed), distances, params_file
              self._k = 0              # realization counter
              self._buf = None         # sweeps of the current realization
              self._pos = 0
              self._gs = None

          def _next(self):
              if self._gs is None:
                  _repo_src()
                  from channel_model import gr_support
                  self._gs = gr_support
              gs = self._gs
              i = self.start_index + self._k
              d = gs.link_distance(self.condition, self.distances, self.seed, i)
              real = gs.realization(self.condition, d, self.seed, i, self.params_file)
              H, gain = gs.sounder_sweeps(real.adps, np.random.default_rng(np.random.SeedSequence(self.seed, spawn_key=(7, i))))
              off = self.nitems_written(0)
              for key, val in (("rid", pmt.from_long(i)), ("d_m", pmt.from_double(d)), ("gain_db", pmt.from_double(gain)),
                               ("truth", pmt.intern(gs.truth_tag(real)))):
                  self.add_item_tag(0, off, pmt.intern(key), val)
              gs.realization.cache_clear()
              self._buf, self._pos = H, 0
              self._k += 1

          def work(self, input_items, output_items):
              out = output_items[0]
              if self._buf is None or self._pos >= self._buf.shape[0]:
                  if self._k >= self.n_channels:
                      return -1                     # WORK_DONE: all realizations sounded
                  self._next()
              n = min(len(out), self._buf.shape[0] - self._pos)
              out[:n] = self._buf[self._pos:self._pos + n]
              self._pos += n
              return n
    condition: condition
    n_channels: n_channels
    start_index: start_index
    seed: seed
    distances: distances
    params_file: params_file
  states: {}
- name: noise
  id: analog_noise_source_x
  parameters:
    type: complex
    noise_type: analog.GR_GAUSSIAN
    amp: 10 ** (-snr_db / 20)
    seed: '1'
  states: {}
- name: noise_vec
  id: blocks_stream_to_vector
  parameters:
    type: complex
    num_items: nf
  states: {}
- name: rx_add
  id: blocks_add_xx
  parameters:
    type: complex
    vlen: nf
  states: {}
- name: ifft
  id: fft_vxx
  parameters:
    type: complex
    fft_size: nf
    forward: 'False'
    window: '[]'
    shift: 'False'
  states: {}
- name: mag2
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nf
  states: {}
- name: norm
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: '[1.0 / nf] * nf'
    vlen: nf
  states: {}
- name: adps_metrics
  id: epy_block
  parameters:
    _source_code: |
      def _repo_src():
          import os, sys
          cands = [os.environ.get("SUBTHZ_REPO", "")]
          try:
              cands.append(os.path.join(os.path.dirname(os.path.abspath(__file__)), ".."))
          except NameError:
              pass
          cwd = os.getcwd()
          cands += [cwd, os.path.join(cwd, ".."), os.path.join(cwd, "..", "..")]
          for c in cands:
              src = os.path.join(c, "src")
              if c and os.path.isdir(os.path.join(src, "channel_model")):
                  if src not in sys.path:
                      sys.path.insert(0, os.path.abspath(src))
                  return os.path.abspath(c)
          raise RuntimeError("cannot find the sub-thz-d2d-channel-model repository; set SUBTHZ_REPO")


      import csv
      import json
      import os
      import numpy as np
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):
          """ADPS assembly, 35 dB MPC threshold and channel metrics (Secs. IV-A, VIII).

          Input: one 1001-bin delay profile |IFFT(H)|^2 / N_f per orientation pair.
          Every 36 x 36 vectors form one ADPS; the metrics are appended to out_csv together with
          the generator's own (truth) metrics carried in the stream tags.
          """

          def __init__(self, out_csv="sounder.csv", condition="los", dr_db=35.0):
              gr.sync_block.__init__(self, name="ADPS + 35 dB taps + channel metrics",
                                     in_sig=[(np.float32, 1001)], out_sig=None)
              self.out_csv, self.condition, self.dr_db = out_csv, condition, float(dr_db)
              self._rows, self._meta, self._acc, self._gs = [], None, [], None

          def _flush(self):
              if self._meta is None or not self._acc:
                  return
              gs = self._gs
              stack = np.concatenate(self._acc, axis=0)
              if stack.shape[0] == 36 * 36:
                  m = gs.metrics_from_sounding(stack, self._meta["gain_db"], dr_db=self.dr_db)
                  row = {"rid": self._meta["rid"], "condition": self.condition, "d_m": self._meta["d_m"],
                         **{f"gr_{k}": v for k, v in m.items()},
                         **{f"truth_{k}": v for k, v in self._meta["truth"].items()}}
                  self._rows.append(row)
              self._acc, self._meta = [], None

          def work(self, input_items, output_items):
              if self._gs is None:
                  _repo_src()
                  from channel_model import gr_support
                  self._gs = gr_support
              x = input_items[0]
              n = len(x)
              start = self.nitems_read(0)
              tags = sorted(self.get_tags_in_window(0, 0, n, pmt.intern("rid")), key=lambda t: t.offset)
              cuts = [t.offset - start for t in tags] + [n]
              prev = 0
              for t, cut in zip([None] + tags, cuts):
                  if t is not None:
                      self._flush()
                      meta = {"rid": pmt.to_long(t.value)}
                      for tt in self.get_tags_in_range(0, t.offset, t.offset + 1):
                          k = pmt.symbol_to_string(tt.key)
                          if k in ("d_m", "gain_db"):
                              meta[k] = pmt.to_double(tt.value)
                          elif k == "truth":
                              meta["truth"] = json.loads(pmt.symbol_to_string(tt.value))
                      self._meta = meta
                  if cut > prev and self._meta is not None:
                      self._acc.append(np.array(x[prev:cut]))
                  prev = cut
              return n

          def stop(self):
              self._flush()
              if self._rows:
                  new = not os.path.exists(self.out_csv)
                  with open(self.out_csv, "a", newline="") as f:
                      w = csv.DictWriter(f, fieldnames=list(self._rows[0]))
                      if new:
                          w.writeheader()
                      w.writerows(self._rows)
              print(f"[sounder sink] wrote {len(self._rows)} channel(s) to {self.out_csv}")
              return True
    out_csv: out_csv
    condition: condition
    dr_db: dr_db
  states: {}

connections:
- [vna, '0', rx_add, '0']
- [noise, '0', noise_vec, '0']
- [noise_vec, '0', rx_add, '1']
- [rx_add, '0', ifft, '0']
- [ifft, '0', mag2, '0']
- [mag2, '0', norm, '0']
- [norm, '0', adps_metrics, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
